options:
  parameters:
    generate_options: qt_gui
    id: sineWaveFlowgraph
    output_language: python
    title: First Flowgraph
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: '145000000'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    start: '144000000'
    step: '1000000'
    stop: '145000000'
    value: center_freq
    widget: dial
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1024000'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\Users\jason\OneDrive\Desktop\ECE-570\LoraProject\GNURadio\LoRaBroadcastRecording
    repeat: 'True'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: '100000'
    fc: samp_rate
    fftsize: '1024'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '32'
    interp: '3'
    type: ccc
  states: {}

connections:
- [blocks_file_source_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
